# Keil uVision project led1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT87F52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(24000000)
  output: led1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 led.c
